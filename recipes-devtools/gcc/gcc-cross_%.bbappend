require gcc-configure-codasip-baremetal.inc
require gcc-codasip-baremetal.inc
